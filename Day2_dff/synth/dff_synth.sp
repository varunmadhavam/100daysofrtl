* SPICE netlist generated by Yosys 0.9+4274 (git sha1 e6dd4db0, gcc 9.3.0-17ubuntu1~20.04 -fPIC -Os)

X0 d rst_n 1 sky130_fd_sc_hd__and2_0
X1 clk d q_no_rst sky130_fd_sc_hd__dfxtp_1
X2 clk 1 q_syn_rst sky130_fd_sc_hd__dfxtp_1
X3 clk d q_asyn_rst rst_n sky130_fd_sc_hd__dfrtp_1

************************
* end of SPICE netlist *
************************
