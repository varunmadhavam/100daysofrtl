* SPICE netlist generated by Yosys 0.9+4081 (git sha1 862e84eb, gcc 9.3.0-17ubuntu1~20.04 -fPIC -Os)

X0 d rst_n 1 sky130_fd_sc_hd__and2_0
X1 clk d dff_inst.q_no_rst sky130_fd_sc_hd__dfxtp_1
X2 clk d dff_inst.q_asyn_rst rst_n sky130_fd_sc_hd__dfrtp_1
X3 clk 1 dff_inst.q_syn_rst sky130_fd_sc_hd__dfxtp_1
V0 clk dff_inst.clk DC 0
V1 d dff_inst.d DC 0
V2 dff_inst.q_asyn_rst q_asyn_rst DC 0
V3 dff_inst.q_no_rst q_no_rst DC 0
V4 dff_inst.q_syn_rst q_syn_rst DC 0
V5 rst_n dff_inst.rst_n DC 0

************************
* end of SPICE netlist *
************************
