* SPICE netlist generated by Yosys 0.9+4081 (git sha1 862e84eb, gcc 9.3.0-17ubuntu1~20.04 -fPIC -Os)

X0 counter_inst.count_o.0 counter_inst.count_next.0 sky130_fd_sc_hd__clkinv_1
X1 counter_inst.count_o.1 counter_inst.count_o.0 counter_inst.count_next.1 sky130_fd_sc_hd__xor2_1
X2 counter_inst.count_o.1 counter_inst.count_o.0 counter_inst.count_o.2 1 sky130_fd_sc_hd__nand3_1
X3 2 counter_inst.count_o.1 counter_inst.count_o.0 counter_inst.count_o.2 sky130_fd_sc_hd__a21oi_1
X4 1 counter_inst.count_next.2 2 sky130_fd_sc_hd__lpflow_isobufsrc_1
X5 counter_inst.count_o.3 1 counter_inst.count_next.3 sky130_fd_sc_hd__xnor2_1
X6 clk counter_inst.count_next.0 counter_inst.count_o.0 rst_n sky130_fd_sc_hd__dfrtp_1
X7 clk counter_inst.count_next.1 counter_inst.count_o.1 rst_n sky130_fd_sc_hd__dfrtp_1
X8 clk counter_inst.count_next.2 counter_inst.count_o.2 rst_n sky130_fd_sc_hd__dfrtp_1
X9 clk counter_inst.count_next.3 counter_inst.count_o.3 rst_n sky130_fd_sc_hd__dfrtp_1
V0 clk counter_inst.clk DC 0
V1 counter_inst.count_o.0 count_o.0 DC 0
V2 counter_inst.count_o.1 count_o.1 DC 0
V3 counter_inst.count_o.2 count_o.2 DC 0
V4 counter_inst.count_o.3 count_o.3 DC 0
V5 rst_n counter_inst.rst_n DC 0

************************
* end of SPICE netlist *
************************
