* SPICE netlist generated by Yosys 0.9+4274 (git sha1 e6dd4db0, gcc 9.3.0-17ubuntu1~20.04 -fPIC -Os)

X0 count.0 count_next.0 sky130_fd_sc_hd__clkinv_1
X1 count.1 count.2 1 count.0 sky130_fd_sc_hd__and3b_1
X2 count.1 count.2 2 sky130_fd_sc_hd__nor2_1
X3 down_next 2 count.0 down 1 sky130_fd_sc_hd__a2bb2oi_1
X4 count.1 down 3 sky130_fd_sc_hd__xor2_1
X5 count_next.0 3 count_next.1 sky130_fd_sc_hd__xnor2_1
X6 count.0 count.1 down 4 sky130_fd_sc_hd__maj3_1
X7 count.2 down 5 sky130_fd_sc_hd__xnor2_1
X8 4 5 count_next.2 sky130_fd_sc_hd__xnor2_1
X9 clk down_next down rst_n sky130_fd_sc_hd__dfrtp_1
X10 clk count_next.0 count.0 rst_n sky130_fd_sc_hd__dfrtp_1
X11 clk count_next.1 count.1 rst_n sky130_fd_sc_hd__dfrtp_1
X12 clk count_next.2 count.2 rst_n sky130_fd_sc_hd__dfrtp_1

************************
* end of SPICE netlist *
************************
