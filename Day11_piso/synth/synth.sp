* SPICE netlist generated by Yosys 0.9+4274 (git sha1 e6dd4db0, gcc 9.3.0-17ubuntu1~20.04 -fPIC -Os)

X0 piso_inst.s_o 1 sky130_fd_sc_hd__clkinv_1
X1 piso_inst.current_state piso_inst.ready_o sky130_fd_sc_hd__clkinv_1
X2 piso_inst.p.7 2 sky130_fd_sc_hd__clkinv_1
X3 valid_i 3 piso_inst.current_state sky130_fd_sc_hd__lpflow_isobufsrc_1
X4 valid_i 4 piso_inst.current_state sky130_fd_sc_hd__nand2b_1
X5 piso_inst.current_state 5 ready_i valid_i sky130_fd_sc_hd__mux2_1
X6 piso_inst.p.7 4 6 sky130_fd_sc_hd__nand2_1
X7 p_i.6 3 7 sky130_fd_sc_hd__nand2_1
X8 piso_inst.p.6 5 8 sky130_fd_sc_hd__nor2_1
X9 9 5 6 8 7 sky130_fd_sc_hd__a31oi_1
X10 piso_inst.p.6 4 10 sky130_fd_sc_hd__nand2_1
X11 p_i.5 3 11 sky130_fd_sc_hd__nand2_1
X12 piso_inst.p.5 5 12 sky130_fd_sc_hd__nor2_1
X13 13 5 10 12 11 sky130_fd_sc_hd__a31oi_1
X14 piso_inst.p.5 4 14 sky130_fd_sc_hd__nand2_1
X15 p_i.4 3 15 sky130_fd_sc_hd__nand2_1
X16 piso_inst.p.4 5 16 sky130_fd_sc_hd__nor2_1
X17 17 5 14 16 15 sky130_fd_sc_hd__a31oi_1
X18 piso_inst.p.4 4 18 sky130_fd_sc_hd__nand2_1
X19 p_i.3 3 19 sky130_fd_sc_hd__nand2_1
X20 piso_inst.p.3 5 20 sky130_fd_sc_hd__nor2_1
X21 21 5 18 20 19 sky130_fd_sc_hd__a31oi_1
X22 piso_inst.p.3 4 22 sky130_fd_sc_hd__nand2_1
X23 p_i.2 3 23 sky130_fd_sc_hd__nand2_1
X24 piso_inst.p.2 5 24 sky130_fd_sc_hd__nor2_1
X25 25 5 22 24 23 sky130_fd_sc_hd__a31oi_1
X26 piso_inst.p.2 4 26 sky130_fd_sc_hd__nand2_1
X27 p_i.1 3 27 sky130_fd_sc_hd__nand2_1
X28 piso_inst.p.1 5 28 sky130_fd_sc_hd__nor2_1
X29 29 5 26 28 27 sky130_fd_sc_hd__a31oi_1
X30 30 piso_inst.p.1 ready_i p_i.0 3 piso_inst.current_state sky130_fd_sc_hd__a32oi_1
X31 31 1 5 30 sky130_fd_sc_hd__o21ai_0
X32 piso_inst.count.0 ready_i piso_inst.current_state 32 sky130_fd_sc_hd__and3_1
X33 piso_inst.count.1 piso_inst.count.0 ready_i piso_inst.current_state 33 sky130_fd_sc_hd__and4_1
X34 piso_inst.count.2 33 34 sky130_fd_sc_hd__nor2_1
X35 piso_inst.count.2 piso_inst.count.1 piso_inst.count.0 35 sky130_fd_sc_hd__nand3_1
X36 piso_inst.current_state 35 36 sky130_fd_sc_hd__nand2_1
X37 37 5 36 34 sky130_fd_sc_hd__a21oi_1
X38 38 piso_inst.count.1 32 4 sky130_fd_sc_hd__o21ai_0
X39 33 38 39 sky130_fd_sc_hd__nor2_1
X40 40 ready_i piso_inst.current_state piso_inst.count.0 sky130_fd_sc_hd__a21oi_1
X41 3 32 40 41 sky130_fd_sc_hd__nor3_1
X42 4 36 piso_inst.next_state sky130_fd_sc_hd__nand2_1
X43 p_i.7 3 42 sky130_fd_sc_hd__nand2_1
X44 43 2 5 42 sky130_fd_sc_hd__o21ai_0
X45 clk piso_inst.next_state piso_inst.current_state rst_n sky130_fd_sc_hd__dfrtp_1
X46 clk 41 piso_inst.count.0 rst_n sky130_fd_sc_hd__dfrtp_1
X47 clk 39 piso_inst.count.1 rst_n sky130_fd_sc_hd__dfrtp_1
X48 clk 37 piso_inst.count.2 rst_n sky130_fd_sc_hd__dfrtp_1
X49 clk 31 piso_inst.s_o rst_n sky130_fd_sc_hd__dfrtp_1
X50 clk 29 piso_inst.p.1 rst_n sky130_fd_sc_hd__dfrtp_1
X51 clk 25 piso_inst.p.2 rst_n sky130_fd_sc_hd__dfrtp_1
X52 clk 21 piso_inst.p.3 rst_n sky130_fd_sc_hd__dfrtp_1
X53 clk 17 piso_inst.p.4 rst_n sky130_fd_sc_hd__dfrtp_1
X54 clk 13 piso_inst.p.5 rst_n sky130_fd_sc_hd__dfrtp_1
X55 clk 9 piso_inst.p.6 rst_n sky130_fd_sc_hd__dfrtp_1
X56 clk 43 piso_inst.p.7 rst_n sky130_fd_sc_hd__dfrtp_1
V0 piso_inst.s_o piso_inst.p.0 DC 0
V1 piso_inst.p.1 piso_inst.p_next.0 DC 0
V2 piso_inst.p.2 piso_inst.p_next.1 DC 0
V3 piso_inst.p.3 piso_inst.p_next.2 DC 0
V4 piso_inst.p.4 piso_inst.p_next.3 DC 0
V5 piso_inst.p.5 piso_inst.p_next.4 DC 0
V6 piso_inst.p.6 piso_inst.p_next.5 DC 0
V7 piso_inst.p.7 piso_inst.p_next.6 DC 0
V8 piso_inst.current_state piso_inst.valid_o DC 0
V9 clk piso_inst.clk DC 0
V10 p_i.0 piso_inst.p_i.0 DC 0
V11 p_i.1 piso_inst.p_i.1 DC 0
V12 p_i.2 piso_inst.p_i.2 DC 0
V13 p_i.3 piso_inst.p_i.3 DC 0
V14 p_i.4 piso_inst.p_i.4 DC 0
V15 p_i.5 piso_inst.p_i.5 DC 0
V16 p_i.6 piso_inst.p_i.6 DC 0
V17 p_i.7 piso_inst.p_i.7 DC 0
V18 ready_i piso_inst.ready_i DC 0
V19 piso_inst.ready_o ready_o DC 0
V20 rst_n piso_inst.rst_n DC 0
V21 piso_inst.s_o s_o DC 0
V22 valid_i piso_inst.valid_i DC 0
V23 piso_inst.valid_o valid_o DC 0

************************
* end of SPICE netlist *
************************
