* SPICE netlist generated by Yosys 0.9+4081 (git sha1 862e84eb, gcc 9.3.0-17ubuntu1~20.04 -fPIC -Os)

X0 clk shiftreg_inst.p_o.1 shiftreg_inst.p_o.0 rst_n sky130_fd_sc_hd__dfrtp_1
X1 clk shiftreg_inst.p_o.2 shiftreg_inst.p_o.1 rst_n sky130_fd_sc_hd__dfrtp_1
X2 clk shiftreg_inst.p_o.3 shiftreg_inst.p_o.2 rst_n sky130_fd_sc_hd__dfrtp_1
X3 clk shiftreg_inst.p_o.4 shiftreg_inst.p_o.3 rst_n sky130_fd_sc_hd__dfrtp_1
X4 clk shiftreg_inst.p_o.5 shiftreg_inst.p_o.4 rst_n sky130_fd_sc_hd__dfrtp_1
X5 clk shiftreg_inst.p_o.6 shiftreg_inst.p_o.5 rst_n sky130_fd_sc_hd__dfrtp_1
X6 clk shiftreg_inst.p_o.7 shiftreg_inst.p_o.6 rst_n sky130_fd_sc_hd__dfrtp_1
X7 clk s_i shiftreg_inst.p_o.7 rst_n sky130_fd_sc_hd__dfrtp_1
V0 shiftreg_inst.p_o.1 shiftreg_inst.p_next.0 DC 0
V1 shiftreg_inst.p_o.2 shiftreg_inst.p_next.1 DC 0
V2 shiftreg_inst.p_o.3 shiftreg_inst.p_next.2 DC 0
V3 shiftreg_inst.p_o.4 shiftreg_inst.p_next.3 DC 0
V4 shiftreg_inst.p_o.5 shiftreg_inst.p_next.4 DC 0
V5 shiftreg_inst.p_o.6 shiftreg_inst.p_next.5 DC 0
V6 shiftreg_inst.p_o.7 shiftreg_inst.p_next.6 DC 0
V7 shiftreg_inst.s_i shiftreg_inst.p_next.7 DC 0
V8 clk shiftreg_inst.clk DC 0
V9 shiftreg_inst.p_o.0 p_o.0 DC 0
V10 shiftreg_inst.p_o.1 p_o.1 DC 0
V11 shiftreg_inst.p_o.2 p_o.2 DC 0
V12 shiftreg_inst.p_o.3 p_o.3 DC 0
V13 shiftreg_inst.p_o.4 p_o.4 DC 0
V14 shiftreg_inst.p_o.5 p_o.5 DC 0
V15 shiftreg_inst.p_o.6 p_o.6 DC 0
V16 shiftreg_inst.p_o.7 p_o.7 DC 0
V17 rst_n shiftreg_inst.rst_n DC 0
V18 s_i shiftreg_inst.s_i DC 0

************************
* end of SPICE netlist *
************************
