* SPICE netlist generated by Yosys 0.9+4274 (git sha1 e6dd4db0, gcc 9.3.0-17ubuntu1~20.04 -fPIC -Os)

X0 sel dut.c b a sky130_fd_sc_hd__mux2_1
V0 a dut.a DC 0
V1 b dut.b DC 0
V2 dut.c c DC 0
V3 sel dut.sel DC 0

************************
* end of SPICE netlist *
************************
