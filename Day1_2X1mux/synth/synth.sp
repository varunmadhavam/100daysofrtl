* SPICE netlist generated by Yosys 0.9+4274 (git sha1 e6dd4db0, gcc 9.3.0-17ubuntu1~20.04 -fPIC -Os)

X0 sel mux2X1_inst.c b a sky130_fd_sc_hd__mux2_1
V0 a mux2X1_inst.a DC 0
V1 b mux2X1_inst.b DC 0
V2 mux2X1_inst.c c DC 0
V3 sel mux2X1_inst.sel DC 0

************************
* end of SPICE netlist *
************************
